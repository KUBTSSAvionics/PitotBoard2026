# Repository KUBTSSAvionics/PitotBoard2026

## KiCad design PitotBoard2026/PitotBoard2026.kicad_pcb

File PitotBoard2026/README.md:

# PitotBoard2026
PitotBoard2026

Parts:
C1, C4, C14, C16, C18, C20, C22, C24: 0.1u; C_0603_1608Metric
C2, C5, C6, C7, C9, C15, C17, C19, C21: 1u; C_0603_1608Metric
C3, C8, C23: 10u; C_0603_1608Metric
C10, C11, C12: 4.7u; C_0603_1608Metric
C27: 100n; C_0603_1608Metric
D1, D2, D6: RB160M; D_SOD-123
D5: ERR; LED_0603_1608Metric
FB1: FerriteBead_Small; L_0603_1608Metric
J1: RJ25; RJ25_Wayconn_MJEA-660X1_Horizontal
J2: ICSP; PinHeader_2x03_P2.54mm_Vertical
J3, J5: Conn_01x04_Socket; PinSocket_1x04_P2.54mm_Vertical
J4, J6: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Horizontal
L1: 10uH; L_Changjiang_FTC322512S
R1, R18: 10k; R_0603_1608Metric
R9: 120; R_0603_1608Metric
R10: 1k; R_0603_1608Metric
R11, R12, R20, R21, R22, R23: 4.7k; R_0603_1608Metric
R13: 10; R_0603_1608Metric
R14: 100; R_0603_1608Metric
R17: 100k; R_0603_1608Metric
SW1: RST; SW_SPST_PTS810
U1: ATmega328PB-A; TQFP-32_7x7mm_P0.8mm
U2: M78AR05-0.5; SIP3_11.6x8.5mm
U3: SDP32
U4, U7: SLIP; SOIC-8_3.9x4.9mm_P1.27mm
U5: TPS76133SF5; SOT-23-5
U9: BME280
U10: MCP25625-x-SS; SSOP-28_5.3x10.2mm_P0.65mm
U11: FXMA2102; DIP-8_W7.62mm
Y1, Y3: 16MHz; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm

Connections:
+3V3: C7.1, C21.1, C22.1, D6.2 (A), J5.2, R18.2, R22.1, R23.1, U5.5 (OUT), U9.1 (VDD), U9.3 (CSB), U10.1 (VIO), U11.8 (VCCB)
+5V: C4.1, C6.1, C8.1, C16.2, C17.2, C19.1, C20.1, D2.2 (A), D6.1 (K), FB1.1, J2.5, J3.4, R1.1, R11.1, R12.1, R13.2, R20.1, R21.1, U1.18 (AVCC), U2.3 (OUT), U4.1 (VDD5V), U5.1 (IN), U5.3 (~EN), U10.19 (VDD), U11.1 (VCCA), U11.4 (OE)
+5VA: C14.1, J4.4, U7.1 (VDD5V)
CANH: J1.4, R9.1, U10.4 (CANH)
CANL: J1.3, R9.2, U10.3 (CANL)
CS: U1.14 (PB2), U10.17 (~CS)
ERR: D5.2 (A), U1.11 (PD7)
GND: C1.2, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C16.1, C17.1, C18.1, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, J1.2, J2.1, J3.1, J5.3, R10.2, R17.2, SW1.1, U1.5 (GND), U1.21 (GND), U2.2 (GND), U4.4 (GND), U4.5 (PGO), U4.8 (DIR), U5.2 (GND), U9.2 (GND), U9.5 (SDO), U10.10 (GND), U10.26 (VSS), U11.5 (GND), Y1.2, Y3.2
GND1: C14.2, C15.2, J4.1, U7.4 (GND), U7.5 (PGO), U7.8 (DIR)
GND2: C27.2, J6.3, U3.1 (GND), U3.2 (GND), U3.3 (GND), U3.6 (GND), U3.9 (ADDR), U3.10 (GND), U3.11 (GND), U3.17 (GND1), U3.18 (GND1)
INT: U1.1 (PD3), U10.13 (~INT)
MISO: J2.6, U1.16 (PB4), U10.16 (SO)
MOSI: J2.3, U1.15 (PB3), U10.15 (SI)
unnamed: D1.2 (A), J1.5
unnamed: C3.1, C9.1, C10.1, C11.1, D1.1 (K), D2.1 (K), L1.1
unnamed: D5.1 (K), R10.1
unnamed: J6.1, U3.8 (SDA)
unnamed: C27.1, J6.2, U3.7 (VDD)
unnamed: J6.4, U3.5 (SCL)
unnamed: C1.1, U1.20 (AREF)
unnamed: C2.2, C18.2, R13.1, U1.4 (VCC)
unnamed: U1.7 (XTAL1/PB6), Y1.3
unnamed: U1.8 (XTAL2/PB7), Y1.1
unnamed: R14.1, U1.29 (~RESET/PC6)
unnamed: C12.1, L1.2, U2.1 (IN)
unnamed: C5.1, U4.2 (VDD3V3)
unnamed: C15.1, U7.2 (VDD3V3)
unnamed: U10.9 (OSC1), Y3.1
unnamed: U10.8 (OSC2), Y3.3
unnamed: U10.21 (RxCAN), U10.28 (RXD)
unnamed: R17.1, U10.5 (STBY)
unnamed: U10.20 (TxCAN), U10.24 (TXD)
unnamed: C23.1, C24.1, FB1.2, U10.27 (VDDA)
unnamed: R18.1, U10.18 (~RESET)
RST: J2.2, R1.2, R14.2, SW1.2
SCK: J2.4, U1.17 (PB5), U10.14 (SCK)
SCL0: J3.2, R20.2, U1.6 (PE1), U11.2 (A0)
SCL1: R12.2, U1.28 (PC5), U4.7 (SCL)
SCL2: J4.2, U7.7 (SCL)
SCL3: J5.4, R22.2, U9.6 (CLK), U11.6 (B0)
SDA0: J3.3, R21.2, U1.3 (PE0), U11.3 (A1)
SDA1: R11.2, U1.27 (PC4), U4.6 (SDA)
SDA2: J4.3, U7.6 (SDA)
SDA3: J5.1, R23.2, U9.4 (SDI), U11.7 (B1)

Notes on the sheet:
C10～C12：データシートで高周波ノイズの発生を防ぐために必要とされてるコンデンサ ClassB
SDOピンをGNDに接続しているため、I2Cアドレスは0x76
I2Cアドレスは固定で0x36
0.125W
R5をはがす
max:150mA
書き込み用
max:500mA
こっちにTWIの2系統目があるので AS5600二つをI2C駆動してもよい
裏面のパッド（PCBエディターでパッド17、18）はGNDにする。

Board: 2 copper layers, 59.7 x 40.2 mm, 61 parts (20 on the bottom side), 44 nets.

## Commit log

2025-10-09 Add files via upload
    試作前完成版 FXMA2102配置
2025-11-06 Add files via upload
    SDP32を配置
2025-11-15 Add files via upload
    フットプリント設定完了
2025-11-15 I2Cのエラーを修正
    5Vを3.3Vの方につないでいたのを修正
2025-11-15 5Vと3.3Vのミスを修正
2025-11-17 配線終わり(部品は違う)
2025-11-17 Add files via upload
    レギュレータ変更。PCBエディターは配線前にリセットした。
2025-11-17 Add files via upload
    Edge Cuts消去
2026-02-13 Add files via upload
    入江さんのフィードバックを回路図に反映
2026-03-09 Add files via upload
    ガーバーファイル作成
2026-04-29 Add files via upload
    FXMA2102とM78ARのフットプリントを修正
2026-05-27 Add files via upload
    MCP25625を5Vに変更。FXMA2102のピン番号を修正。
